# Keil uVision project ROLLERCAN.uvprojx, settings and files
target ROLLERCAN (6090000::V6.9::.\ARMCLANG)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: ROLLERCAN +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o .\ROLLERCAN\ROLLERCAN.bin .\ROLLERCAN\ROLLERCAN.axf
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../MyFile/inc;../Drivers/CMSIS/DSP/Include;../U8g2_lib
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x1e000
  memory RVCT9: RAM 0x200000c0 size 0x7f40
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../MyFile/src/: ws2812.c
    ../Core/Src/: i2c_ex.c flash.c main.c gpio.c adc.c dma.c fdcan.c i2c.c spi.c tim.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_ll_utils.c stm32g4xx_ll_exti.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_fdcan.c stm32g4xx_ll_i2c.c stm32g4xx_ll_gpio.c stm32g4xx_ll_dma.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group MyFiles
    ../MyFile/src/: motordriver.c mysys.c myadc.c oled_u8g2.c u8g2_disp_fun.c encoder.c motion_estimator.c button.c pid_controller.c smart_knob.c frictionless_hold.c tle5012b.c
  group U8g2_lib
    ../U8g2_lib/: mui.c mui_u8g2.c u8g2_arc.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_64x48.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
software components: CMSIS:CORE 5.6.0
